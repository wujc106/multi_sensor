# IAR project Project.ewp, settings and files
configuration GD32F5HC (ARM, debug)
  General.OGChipSelectEditMenu: GD32F5HCxI GD GD32F5HCxI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; FW_DEBUG_ERR_REPORT; SYS_NS; GD32F5HC; LV_CONF_INCLUDE_SIMPLE; LV_LVGL_H_INCLUDE_SIMPLE; LV_DEMO_CONF_INCLUDE_SIMPLE
  ICCARM.CCDiagSuppress: Pa089,Pe177,Pa084,Pe546,Pe188,Pa118,Pe111,Pe236,Pe550
  ICCARM.CCIncludePath2: ..; ..\..\Utilities; ..\..\Firmware\GD32W51x_F5HC_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32W51x_F5HC\Include; ..\..\Utilities\BSP_Drive; ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32W51x_F5HC\Source\IAR; ..\..\Utilities\Third_Party\lvgl; ..\..\Utilities\Third_Party\lvgl\port; ..\..\Utilities\Third_Party\lvgl\lvgl_src; ..\..\Utilities\Third_Party\lvgl\lvgl_src\src; ..\..\Utilities\Third_Party\lvgl\lvgl_src\demos; ..\..\Utilities\Third_Party\lvgl\lvgl_src\examples; ..\GUI_APP\GD32EmbeddedUI; ..\GUI_APP\GD32EmbeddedUI\custom; ..\GUI_APP\GD32EmbeddedUI\generated
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: GD32F5HCxI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32W515 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32W515xI GD GD32W515xI
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; FW_DEBUG_ERR_REPORT; SYS_NS; GD32W515
  ICCARM.CCIncludePath2: ..; ..\..\Utilities; ..\..\Firmware\GD32W51x_F5HC_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32W51x_F5HC\Include
  group Application
    ../: gd32w51x_f5hc_it.c main.c systick.c
  group BSP_Drive
    ../../Utilities/BSP_Drive/: gd32f5hcr_eval.c lcd_driver.c
  group CMSIS
    ../../Firmware/CMSIS/GD/gd32w51x_f5hc/Source/: gd32w51x_f5hc_err_report.c system_gd32w51x_f5hc.c
  group Doc
    ../: readme.txt
  group GD32W51x_Peripherals
    ../../Firmware/gd32w51x_f5hc_standard_peripheral/Source/: gd32w51x_f5hc_adc.c gd32w51x_f5hc_cau.c gd32w51x_f5hc_cau_aes.c gd32w51x_f5hc_cau_des.c gd32w51x_f5hc_cau_tdes.c gd32w51x_f5hc_crc.c gd32w51x_f5hc_ctc.c gd32w51x_f5hc_dbg.c gd32w51x_f5hc_dci.c gd32w51x_f5hc_dma.c gd32w51x_f5hc_efuse.c gd32w51x_f5hc_exti.c gd32w51x_f5hc_fmc.c gd32w51x_f5hc_fwdgt.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_hau.c gd32w51x_f5hc_hau_sha_md5.c gd32w51x_f5hc_hpdf.c gd32w51x_f5hc_i2c.c gd32w51x_f5hc_icache.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_pkcau.c gd32w51x_f5hc_pmu.c gd32w51x_f5hc_qspi.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_rtc.c gd32w51x_f5hc_sdio.c gd32w51x_f5hc_spi.c gd32w51x_f5hc_sqpi.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_timer.c gd32w51x_f5hc_trng.c gd32w51x_f5hc_tsi.c gd32w51x_f5hc_tzpcu.c gd32w51x_f5hc_usart.c gd32w51x_f5hc_wwdgt.c
  group GUI_APP/custom
    ../GUI_APP/GD32EmbeddedUI/custom/: gui_app.c
  group GUI_APP/generated
    ../GUI_APP/GD32EmbeddedUI/generated/lang/: aic_lang.c font_list.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/: event.c
    ../GUI_APP/GD32EmbeddedUI/generated/font/: font_notosanscjksc_regular_14_b49ae336.c font_notosanscjksc_regular_14_b49ae336_fb3f.c font_notosanscjksc_regular_16_b49ae336.c font_notosanscjksc_regular_16_b49ae336_fb3f.c
    ../GUI_APP/GD32EmbeddedUI/generated/image/: gif_wave.c img_20260805_154005_fit_78x102.c img_20260901_191444_fit_107x89.c img_balloon_fit_30x26.c img_bluetoothon_fit_36x34.c img_brightness_fit_36x34.c img_clock_fit_36x34.c img_drawing_fit_30x26.c img_fireworks_fit_30x26.c img_rocket_fit_30x26.c img_shape_fit_30x26.c img_slide_fit_30x26.c img_tv_fit_30x26.c img_warning_fit_30x26.c img_wifi_fit_36x34.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen/: screen.c screen_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen1/: screen_1.c screen_1_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen2/: screen_2.c screen_2_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen3/: screen_3.c screen_3_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen4/: screen_4.c screen_4_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen5/: screen_5.c screen_5_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen6/: screen_6.c screen_6_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/screens/screen7/: screen_7.c screen_7_event.c
    ../GUI_APP/GD32EmbeddedUI/generated/theme/: theme.c
    ../GUI_APP/GD32EmbeddedUI/generated/: ui_init.c ui_util.c
  group lvgl/demo
    ../../Utilities/Third_Party/lvgl/lvgl_src/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/demos/benchmark/: lv_demo_benchmark.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/demos/widgets/: lv_demo_widgets.c
  group lvgl/port
    ../../Utilities/Third_Party/lvgl/port/: lv_port_disp.c lv_port_indev.c
  group lvgl/src/core
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/src/extra
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/animimg/: lv_animimg.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/bmp/: lv_bmp.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/chart/: lv_chart.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/: lv_extra.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/layouts/flex/: lv_flex.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/freetype/: lv_freetype.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/layouts/grid/: lv_grid.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/gridnav/: lv_gridnav.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/imgfont/: lv_imgfont.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/led/: lv_led.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/list/: lv_list.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/menu/: lv_menu.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/meter/: lv_meter.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/monkey/: lv_monkey.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/msg/: lv_msg.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/snapshot/: lv_snapshot.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/span/: lv_span.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/spinner/: lv_spinner.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/tabview/: lv_tabview.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/themes/basic/: lv_theme_basic.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/themes/default/: lv_theme_default.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/themes/mono/: lv_theme_mono.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/tileview/: lv_tileview.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/win/: lv_win.c
  group lvgl/src/font
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgl/src/hal
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Startup
    ../../Firmware/CMSIS/GD/gd32w51x_f5hc/Source/IAR/: startup_gd32f5hc.s startup_gd32w515.s
